# Keil uVision project DDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: NEW_AD9851 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source
  group Source Group 1
    ./source/: main.c DDS9851.C bsp_seg.c
